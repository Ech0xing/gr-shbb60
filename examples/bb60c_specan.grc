options:
  parameters:
    generate_options: qt_gui
    id: bb60c_specan
    output_language: python
    title: BB60C Spectrum Analyzer
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency [Hz]
    start: 70e6
    step: 10e6
    stop: 6e9
    value: 2.425e9
  states: {}
- name: decimation
  id: variable_qtgui_chooser
  parameters:
    label: Sample Rate (Decimation)
    labels: '["40 MS/s (1)","20 MS/s (2)","10 MS/s (4)","5 MS/s (8)","2.5 MS/s (16)","1.25 MS/s (32)","625 KS/s (64)","312.5 KS/s (128)","156.25 KS/s (256)","78.125 KS/s (512)","39,062.5 S/s (1024)","19,531.25 S/s (2048)","9,765.625 S/s (4096)","4,882.8125 S/s (8192)"]'
    num_opts: '0'
    options: '[1,2,4,8,16,32,64,128,256,512,1024,2048,4096,8192]'
    type: int
    value: '2'
  states: {}
- name: filter_bw
  id: variable
  parameters:
    value: '{1:27e6, 2:17.8e6, 4:8e6, 8:3.75e6, 16:2e6, 32:1e6, 64:0.5e6, 128:0.25e6, 256:140e3, 512:65e3, 1024:30e3, 2048:15e3, 4096:8e3, 8192:4e3}[decimation]'
  states: {}
- name: ref_level
  id: variable_qtgui_range
  parameters:
    label: Reference Level (dBm)
    start: '-80.0'
    step: '0.1'
    stop: '20.0'
    value: '-30.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6/decimation
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '4096'
    name: '"Spectrum"'
    type: complex
    update_time: '0.010'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    name: '"Waterfall"'
    type: complex
    update_time: '0.010'
  states: {}
- name: shbb60_bb60c_source_0
  id: shbb60_bb60c_source
  parameters:
    center_freq: center_freq
    decimation: decimation
    filter_bw: filter_bw
    ref_level: ref_level
  states: {}

connections:
- [shbb60_bb60c_source_0, '0', qtgui_freq_sink_x_0, '0']
- [shbb60_bb60c_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.6.0
