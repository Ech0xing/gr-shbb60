options:
  parameters:
    generate_options: qt_gui
    id: bb60c_specan
    output_language: python
    title: BB60C Spectrum Analyzer
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /root/signal_hound/examples/sh_capture.cf32
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '8192'
    type: complex
    update_time: '0.010'
  states: {}
- name: shbb60_bb60c_source_0
  id: shbb60_bb60c_source
  parameters:
    center_freq: '2425000000.0'
    decimation: '4'
    filter_bw: '8000000.0'
    ref_level: '-20.0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [shbb60_bb60c_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.6.0
